v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 420 -110 420 -80 { lab=in}
N 420 -20 420 0 { lab=out}
N 420 -0 420 30 { lab=out}
C {iopin.sym} 420 -110 3 0 {name=p2 lab=in}
C {iopin.sym} 420 30 1 0 {name=p1 lab=out}
C {sky130_fd_pr/cap_mim_m3_1.sym} 420 -50 0 0 {name=C1 model=cap_mim_m3_1 W=20 L=20 MF=9 spiceprefix=X}
